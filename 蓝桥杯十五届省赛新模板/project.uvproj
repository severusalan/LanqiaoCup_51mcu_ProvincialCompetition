# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    D:/7T Plan/Plan/1_真题/0_3_V4T_Me_练习版_仅源码/: ch138.c ch138.h ds1302.c ds1302.h iic.c iic.h init.c init.h key.c key.h led.c led.h main.c onewire.c onewire.h seg.c seg.h uart.c uart.h ultrawave.c ultrawave.h
